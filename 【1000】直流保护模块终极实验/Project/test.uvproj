# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H3K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0BFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: test +hex
  c flags: Optimize=1 SizeSpeed=1
  group Source Group 1
    ../User/led/: Bsp_led.c
    ../User/: main.c
    ../User/key/: Bsp_key.c
    ../User/lcd/: Bsp_lcd.c
    ../User/adc/: Bsp_adc.c
    ../User/relay/: Bsp_relay.c
    ../User/uart/: Bsp_uart.c
    ../User/lap/: Bsp_lap.c
